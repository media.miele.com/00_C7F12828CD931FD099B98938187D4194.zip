Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: f6fda739-ea29-46bd-a4dd-82052bd730dc, NumberOfSaves: 1]
File name: 0001
Time: 2025-07-18T09:51:30+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12904820_D_KMDA7676-1FL:26767675_D_12904820_KMDA7676-1FL, (2)
In: Default
Type - Material: z_Miele_Design_CLST, z_Miele_Design_print, z_Miele_Design_OBSW, <Unnamed>, z_Miele_Connection_Electric
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 800 mm; Height: 238 mm; Depth: 520 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 26767675_D_12904820_KMDA7676-1FL; sets with these values: 2
